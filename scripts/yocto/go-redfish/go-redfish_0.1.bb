require go-redfish.inc

LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

#SRC_URI[md5sum] = "e731c68a8b71af66ee5642bd4547583c"
#SRC_URI[sha256sum] = "6a7b8096484469db167567ba0f60176586b4641c2601ed09c9ebea31385a7cc7"

BB_STRICT_CHECKSUM = "0"
